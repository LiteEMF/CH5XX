# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: ch5xx +hex
  c flags: Optimize=9
  c include: ../user;../user/emf_ch5xx_hal;../user/LiteEMF;../user/LiteEMF/app;../user/LiteEMF/api;../user/LiteEMF/utils;../user/LiteEMF/utils/std_include
  link misc: REMOVEUNUSED
  group main
    ./: main.c
    ../user/project/: gamepad1.c
  group emf_app
    ../user/LiteEMF/app/: app_battery.c app_command.c app_joystick.c app_key.c app_km.c app_led.c app_rumble.c emf.c io_key.c io_keyboard.c
    ../user/LiteEMF/app/adb/: adb_auth_sign.c app_adb.c
    ../user/LiteEMF/app/gamepad/: app_gamepad.c app_gamepad_key.c gamepad_controller.c ps_controller.c ps_crypt.c switch_controller.c switch_device.c switch_host.c switch_nfc.c turbo.c xbox_command.c xbox_controller.c xbox_device.c xbox_host.c
    ../user/LiteEMF/app/iap2/: app_iap2.c iap2_packet.c
    ../user/LiteEMF/app/imu/: app_imu.c imu_driver.c sh3001.c
    ../user/LiteEMF/app/rgb/: app_rgb.c color_utils.c rgb_driver.c
    ../user/LiteEMF/app/usbmuxd/: usbmuxd.c
  group emf_api
    ../user/LiteEMF/api/: api_adc.c api_commander.c api_flash.c api_gpio.c api_iic_host.c api_log.c api_pm.c api_pwm.c api_soft_timer.c api_spi_host.c api_storage.c api_system.c api_tick.c api_timer.c api_transport.c api_uart.c api_wdt.c pinmap.c
    ../user/LiteEMF/api/audio/: api_audio.c
    ../user/LiteEMF/api/hid/: hid_desc_parser.c hid_dev_desc.c
    ../user/LiteEMF/api/nfc/: api_nfc.c nfc_driver.c
    ../user/LiteEMF/api/usb/: usbd_socket.c usbh_socket.c
    ../user/LiteEMF/api/usb/host/: usbh.c usbh_adb.c usbh_aoa.c usbh_audio.c usbh_cdc.c usbh_class.c usbh_core.c usbh_hid.c usbh_hid_gamepad.c usbh_hid_km.c usbh_hub.c usbh_iap2.c usbh_msd.c usbh_printer.c usbh_usbmuxd.c usbh_vendor.c
    ../user/LiteEMF/api/usb/device/: usbd.c usbd_audio.c usbd_auto.c usbd_cdc.c usbd_class.c usbd_core.c usbd_hid.c usbd_hid_gamepade.c usbd_hid_km.c usbd_hid_mt.c usbd_hid_ps.c usbd_hid_switch.c usbd_hid_vendor.c usbd_hid_x360.c usbd_hid_xbox.c usbd_iap2.c usbd_msd.c usbd_printer.c usbd_msd_scsi.c usbd_msd_ram_disk.c
  group emf_utils
    ../user/LiteEMF/utils/: app_fifo.c at_commander.c check_sum.c emf_error.c emf_math.c emf_utils.c filter.c vector.c
    ../user/LiteEMF/utils/mem/: emf_mem.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../user/LiteEMF/utils/crc/: crc_poly.c crc8.c crc16.c crc32.c
  group emf_ch5xx_hal
    ../user/emf_ch5xx_hal/: hal_adc.c hal_audio.c hal_bt.c hal_flash.c hal_gpio.c hal_iic_host.c hal_log.c hal_mem.c hal_pm.c hal_pwm.c hal_spi_host.c hal_system.c hal_tick.c hal_timer.c hal_uart.c hal_wdt.c
    ../user/emf_ch5xx_hal/usb/: hal_usbd.c hal_usbh.c
